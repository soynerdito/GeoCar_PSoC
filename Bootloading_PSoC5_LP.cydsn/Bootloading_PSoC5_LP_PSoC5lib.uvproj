# Keil uVision project Bootloading_PSoC5_LP_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868LTI-LP039 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x2800-0x3FFBF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Bootloading_PSoC5_LP_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h Bootloadable_1.c Bootloadable_1.h PWM_1.c PWM_1.h PWM_1_PM.c Clock_1.c Clock_1.h STATUS_LED_aliases.h STATUS_LED.c STATUS_LED.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h
target Release (ARM-GNU)
  device: CY8C5868LTI-LP039 Cypress
  cpu: as above
  output: Bootloading_PSoC5_LP_PSoC5lib (library)
